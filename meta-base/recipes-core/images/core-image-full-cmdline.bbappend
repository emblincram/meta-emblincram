IMAGE_INSTALL:append = " kernel-modules"
IMAGE_INSTALL:append = " curl"
